# Repository yassan802/DRC-DCMD2026.2ch-2E

File README.md:

# DRC-DCMD2026.2ch-2E
DCモータ用のモータドライバの回路図データです。KiCad9.0を用いて作成しました。
チャンネル数は２つ、エンコーダも２つ接続することができます。
マイコンにはSTM32F303K8T6を用いており、エンコーダモードが使用可能です。

## KiCad design DRC-DCMD2026.2ch-2E.kicad_pcb

Parts:
C1, C9: 0.47u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C5, C6, C7, C8, C10, C12, C18, C19, C24, C25, C28: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4: 2.2u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C13, C20, C21, C22, C23: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C14, C15, C16, C17: 220u; CP_Radial_D8.0mm_P3.50mm
D1: 1N4148WT; D_SOD-123
D2, D6, D7, D10, D11, D12: SS2040FL; D_SOD-123F
D3: 1N4148; D_SOD-123
D4, D5, D8, D9: LED_Small; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
F1: 30A; 3557-15
J1: Conn_01x06_Socket; IDC-Header_2x03_P2.54mm_Vertical
J2: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J3: B; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J4, J12: A; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J7, J8: Conn_01x04_Pin; JST_XH_S4B-XH-A-1_1x04_P2.50mm_Horizontal
J9: Vm; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
J10, J11: OUTPUT; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
JP1: TRM; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2: REG; SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm_NumberLabels
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8: NMOS; TO-252-2
R1, R2: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R5, R8, R17: R_Small; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6, R7, R26, R27: 1; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9, R10, R11, R12, R22, R23, R24, R25: 47; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13, R14, R15, R16, R18, R19, R20, R21, R28: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R34, R35: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_Push; SW_SPST_EVQPE1
SW5: SW_SPDT; SW_SS-12D00-G5
SW6: SW_DIP_x02; SW_DIP_SPSTx02_Slide_Copal_CHS-02B_W7.62mm_P1.27mm
U1: LF33_TO252; TO-252-3_TabPin2
U2: MCP2562-H-SN; SOIC-8_3.9x4.9mm_P1.27mm
U3: STM32F303K8Tx; LQFP-32_7x7mm_P0.8mm
U4: L7812; TO-252-3_TabPin2
U5: CH340E; MSOP-10_3x3mm_P0.5mm
U6, U7, U8, U9: IR2302; SOIC-8_3.9x4.9mm_P1.27mm
U10: TLP185; SOIC-4_4.55x3.7mm_P2.54mm
Y2: Resonator_Small; Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm_HandSoldering

Connections:
+3.3V: C2.2, C4.1, C6.2, C7.2, C8.2, C10.2, D1.2 (A), D9.2 (A), J1.3, R28.1, SW5.1 (A), U1.3 (VO), U2.5 (Vio), U3.1 (VDD), U3.5 (VDDA), U3.17 (VDD), U5.7 (VCC), U5.10 (V3); also elsewhere on the board
+5V: C1.1, C5.2, D1.1 (K), D2.1 (K), D5.2 (A), D12.1 (K), J7.4, J8.4, U1.1 (VI), U2.3 (VDD), U10.6; also elsewhere on the board
+12V: C18.2, C19.2, C24.2, C25.2, JP2.2 (C), R6.1, R7.1, R26.1, R27.1, U6.1 (VCC), U7.1 (VCC), U8.1 (VCC), U9.1 (VCC); also elsewhere on the board
+BATT: C9.1, C14.1, C15.1, C16.1, C17.1, D3.1 (K), D8.2 (A), F1.1, JP2.3 (B), Q1.2 (D), Q3.2 (D), Q5.2 (D), Q7.2 (D), U4.1 (IN), U10.1
CAN_H: J7.3, J8.3, JP1.1 (A), U2.7 (CANH)
CAN_L: J7.2, J8.2, R3.2, U2.6 (CANL)
CAN_RX: U2.4 (RXD), U3.21 (PA11)
CAN_TX: U2.1 (TXD), U3.22 (PA12)
ENC_A0: U3.6 (PA0); also elsewhere on the board
ENC_A1: U3.10 (PA4); also elsewhere on the board
ENC_B0: U3.7 (PA1); also elsewhere on the board
ENC_B1: U3.12 (PA6); also elsewhere on the board
ENC_X0: U3.29 (PB6); also elsewhere on the board
ENC_X1: U3.30 (PB7); also elsewhere on the board
GND: C1.2, C2.1, C4.2, C5.1, C6.1, C7.1, C8.1, C10.1, C28.2, J1.1, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), J3.2, J4.2, J7.1, J8.1, J12.2, R1.2, R2.1, R4.2, R5.2, R17.2, R34.2, SW1.1, SW5.3 (C), SW6.3, SW6.4, U1.2 (GND), U2.2 (VSS), U2.8 (STBY), U3.16 (VSS), U3.32 (VSS), U5.3 (GND), Y2.2; also elsewhere on the board
GNDPWR: C9.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.1, C19.1, C24.1, C25.1, J9.1, Q2.3 (S), Q4.3 (S), Q6.3 (S), Q8.3 (S), R8.2, R14.2, R16.2, R19.2, R21.2, R35.2, U4.2 (GND), U6.4 (COM), U7.4 (COM), U8.4 (COM), U9.4 (COM); also elsewhere on the board
LED: D4.2 (A), U3.25 (PA15)
unnamed: D2.2 (A), J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS)
unnamed: C12.1, C13.1, D3.2 (A), JP2.1 (A), U4.3 (OUT)
unnamed: D4.1 (K), R4.1
unnamed: D5.1 (K), R5.1
unnamed: D6.2 (A), R6.2
unnamed: C20.1, D6.1 (K), U6.8 (VB)
unnamed: D7.2 (A), R7.2
unnamed: C21.1, D7.1 (K), U7.8 (VB)
unnamed: D8.1 (K), R8.1
unnamed: D9.1 (K), R17.1
unnamed: D10.2 (A), R26.2
unnamed: C22.1, D10.1 (K), U8.8 (VB)
unnamed: D11.2 (A), R27.2
unnamed: C23.1, D11.1 (K), U9.8 (VB)
unnamed: D12.2 (A), J1.2
unnamed: J2.A5 (CC1), R1.1
unnamed: J2.B5 (CC2), R2.2
unnamed: F1.2, J9.2
unnamed: C22.2, J10.1, Q5.3 (S), Q6.2 (D), R18.2, U8.6 (VS)
unnamed: C20.2, J10.2, Q1.3 (S), Q2.2 (D), R13.2, U6.6 (VS)
unnamed: C23.2, J11.1, Q7.3 (S), Q8.2 (D), R20.2, U9.6 (VS)
unnamed: C21.2, J11.2, Q3.3 (S), Q4.2 (D), R15.2, U7.6 (VS)
unnamed: JP1.2 (B), R3.1
unnamed: Q1.1 (G), R9.1, R13.1
unnamed: Q2.1 (G), R10.1, R14.1
unnamed: Q3.1 (G), R11.1, R15.1
unnamed: Q4.1 (G), R12.1, R16.1
unnamed: Q5.1 (G), R18.1, R22.1
unnamed: Q6.1 (G), R19.1, R23.1
unnamed: Q7.1 (G), R20.1, R24.1
unnamed: Q8.1 (G), R21.1, R25.1
unnamed: R35.1, U10.3
unnamed: SW5.2 (B), U3.31 (BOOT0)
unnamed: SW6.2, U3.11 (PA5)
unnamed: SW6.1, U3.13 (PA7)
unnamed: U3.2 (PF0), Y2.1
unnamed: U3.3 (PF1), Y2.3
unnamed: R9.2, U6.7 (HO)
unnamed: R10.2, U6.5 (LO)
unnamed: R11.2, U7.7 (HO)
unnamed: R12.2, U7.5 (LO)
unnamed: R22.2, U8.7 (HO)
unnamed: R23.2, U8.5 (LO)
unnamed: R24.2, U9.7 (HO)
unnamed: R25.2, U9.5 (LO)
PWML0_IN: U3.8 (PA2); also elsewhere on the board
PWML0_OUT: U6.2 (IN); also elsewhere on the board
PWML1_IN: U3.14 (PB0); also elsewhere on the board
PWML1_OUT: U7.2 (IN); also elsewhere on the board
PWMN0_IN: U3.9 (PA3); also elsewhere on the board
PWMN0_OUT: U8.2 (IN); also elsewhere on the board
PWMN1_IN: U3.15 (PB1); also elsewhere on the board
PWMN1_OUT: U9.2 (IN); also elsewhere on the board
RESET: C28.1, J1.4, R28.2, SW1.2, U3.4 (NRST)
SWCLK: J1.5, U3.24 (PA14)
SWDIO: J1.6, U3.23 (PA13)
SW_A: J12.1, U3.26 (PB3)
SW_B: J4.1, U3.27 (PB4)
SW_C: J3.1, U3.28 (PB5)
UART_RX: U3.20 (PA10), U5.8 (TXD)
UART_TX: U3.19 (PA9), U5.9 (RXD)
USB_D_N: J2.A7 (D-), J2.B7 (D-), U5.2 (UD-)
USB_D_P: J2.A6 (D+), J2.B6 (D+), U5.1 (UD+)
VM: R34.1, U3.18 (PA8), U10.4

Notes on the sheet:
MOSFET×4: MTB7D0N6RJ3
driver
FTピン（LQFP32):PA8、PA9、PA10、PA11、PA12、PA13、PB3、PB4、PB5 FTfピン（LQFP32、FM＋対応）:PA14、PA15、PB6、PB7

Parts:
C31, C33: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J5: ENC0; JST_XH_S5B-XH-A_1x05_P2.50mm_Horizontal
U13: SN74LVC2T45DCUR; VSSOP-8_2.3x2mm_P0.5mm

Connections:
+3.3V: C31.2, U13.1 (VCCA); also elsewhere on the board
+5V: C33.1, J5.4, U13.8 (VCCB); also elsewhere on the board
ENC_A0: U13.2 (A1); also elsewhere on the board
ENC_B0: U13.3 (A2); also elsewhere on the board
ENC_X0: J5.2; also elsewhere on the board
GND: C31.1, C33.2, J5.1, U13.4 (GND), U13.5 (DIR); also elsewhere on the board
unnamed: J5.3, U13.7 (B1)
unnamed: J5.5, U13.6 (B2)

Parts of its further copies:
C32, C34: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J6: ENC0; JST_XH_S5B-XH-A_1x05_P2.50mm_Horizontal
U18: SN74LVC2T45DCUR; VSSOP-8_2.3x2mm_P0.5mm

Connections of its further copies:
+3.3V: C32.2, U18.1 (VCCA); also elsewhere on the board
+5V: C34.1, J6.4, U18.8 (VCCB); also elsewhere on the board
ENC_A1: U18.2 (A1); also elsewhere on the board
ENC_B1: U18.3 (A2); also elsewhere on the board
ENC_X1: J6.2; also elsewhere on the board
GND: C32.1, C34.2, J6.1, U18.4 (GND), U18.5 (DIR); also elsewhere on the board
unnamed: J6.3, U18.7 (B1)
unnamed: J6.5, U18.6 (B2)

Notes on the sheet:
ENC_B
ENC_A

Parts:
C26, C27: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R30, R31: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U11, U12: TLP2348; SO-5-6_4.55x3.7mm_P1.27mm

Connections:
+12V: C26.2, C27.2, U11.6 (VDD), U12.6 (VDD); also elsewhere on the board
GND: U11.3 (K), U12.3 (K); also elsewhere on the board
GNDPWR: C26.1, C27.1, U11.4 (GND), U12.4 (GND); also elsewhere on the board
unnamed: R30.2, U11.1 (A)
unnamed: R31.2, U12.1 (A)
PWML0_IN: R30.1; also elsewhere on the board
PWML0_OUT: U11.5 (VO); also elsewhere on the board
PWMN0_IN: R31.1; also elsewhere on the board
PWMN0_OUT: U12.5 (VO); also elsewhere on the board

Parts of its further copies:
C29, C30: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R32, R33: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U14, U15: TLP2348; SO-5-6_4.55x3.7mm_P1.27mm

Connections of its further copies:
+12V: C29.2, C30.2, U14.6 (VDD), U15.6 (VDD); also elsewhere on the board
GND: U14.3 (K), U15.3 (K); also elsewhere on the board
GNDPWR: C29.1, C30.1, U14.4 (GND), U15.4 (GND); also elsewhere on the board
unnamed: R32.2, U14.1 (A)
unnamed: R33.2, U15.1 (A)
PWML1_IN: R32.1; also elsewhere on the board
PWML1_OUT: U14.5 (VO); also elsewhere on the board
PWMN1_IN: R33.1; also elsewhere on the board
PWMN1_OUT: U15.5 (VO); also elsewhere on the board

Board: 2 copper layers, 100.0 x 70.0 mm, 122 parts (75 on the bottom side), 89 nets.

Other parts of the board:
SW2: SW_Wuerth_450301014042; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm

## Commit log

2026-04-19 clean start
